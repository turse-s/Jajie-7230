# Keil uVision project PT_HIAC.uvprojx, settings and files
target PT_HIAC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP_PT7280_2_7_2025_2025_4_14_16_15_0 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c include: .\CORE;.\STM32F4xx_StdPeriph_Driver\inc;.\SYSTEM\sys;.\SYSTEM\delay;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\UCOS_BSP;.\UCOSIII\uCOS_CONFIG;.\UCOSIII\uCOS-III;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;.\USER;.\USER\UserCode;.\USER\UserCode;.\Functions
  memory RVCT4: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./USER/: main.c stm32f4xx_it.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
    ./USER/UserCode/: JQueue.c
  group app
    ./USER/UserCode/: TaskStart.c TaskCAN.c TaskAnalyze.c TaskUSART1.c TaskUSART3.c TaskUSART2.c TaskUSART_TX.c TaskEncoder.c TaskMotor.c TaskTimer.c TaskLedState.c
  group Parameter
    ./USER/UserCode/: parameters.c CRC16.c
  group Hardware
    ./USER/UserCode/: hardware.c 24LCxx.c AS5600.c stmflash.c SHT30.c MT6825.c Filter.c laser.c
  group STM32F4xx_Core
    ./CORE/: startup_stm32f40_41xxx.s
    ./USER/: system_stm32f4xx.c
  group STM32F4xx_Library
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uCOSIII_BSP
    ./UCOSIII/UCOS_BSP/: bsp.c
  group uCOSIII_CPU
    ./UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ./UCOSIII/uC-CPU/: cpu_core.c
  group uCOSIII_LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOSIII_CORE
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c
  group uCOSIII_PORT
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOSIII_CONFIG
    ./UCOSIII/uCOS_CONFIG/: os_app_hooks.c
  group Functions
    ./Functions/: Huanyu.c RockerControl.c SpecialFuctions.c ShiHui.c PID.c PID.h
